require diagnostics.inc

DESCRIPTION = "diagnostic_updater contains tools for easily updating diagnostics. it is commonly used in device drivers to keep track of the status of output topics, device status, etc."
HOMEPAGE = "http://www.ros.org/wiki/diagnostic_updater?distro=fuerte"
DEPENDS += ""
PR = "r0"

SRCNAME="diagnostic_updater"

