require diagnostics.inc

DESCRIPTION = "A self_test is a service call provided by a node that triggers a test of the driver and any associated hardware"
HOMEPAGE = "http://www.ros.org/wiki/self_test"
DEPENDS += "ros-fuerte-diagnostic-updater"
PR = "r2"

SRCNAME="self_test"

