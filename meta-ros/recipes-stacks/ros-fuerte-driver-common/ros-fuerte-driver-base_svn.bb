require driver_common.inc

DESCRIPTION = "A framework for writing drivers that helps with runtime reconfiguration, diagnostics and self-test"
HOMEPAGE = "http://ros.org/wiki/driver_base?distro=fuerte"
DEPENDS += "ros-fuerte-self-test ros-fuerte-dynamic-reconfigure"
PR = "r1"

SRCNAME="driver_base"

