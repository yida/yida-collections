require bond_core.inc

DESCRIPTION = "C++ implementation of bond, a mechanism for checking when another process has terminated."
HOMEPAGE = "http://ros.org/wiki/bondcpp?distro=fuerte"
DEPENDS += "ros-fuerte-bond ros-fuerte-smclib"
PR = "r6"

SRCNAME="bondcpp"

