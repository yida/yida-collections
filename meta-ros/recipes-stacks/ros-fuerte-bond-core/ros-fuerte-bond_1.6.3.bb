require bond_core.inc

DESCRIPTION = "C++ implementation of bond, a mechanism for checking when another process has terminated."
HOMEPAGE = "http://ros.org/wiki/bondcpp?distro=fuerte"
DEPENDS += ""
PR = "r0"

SRCNAME="bond"

