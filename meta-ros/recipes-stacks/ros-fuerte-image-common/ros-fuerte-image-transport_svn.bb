require image_common.inc

DESCRIPTION = "image_transport should always be used to subscribe to and publish images"
HOMEPAGE = "http://www.ros.org/wiki/image_transport"
DEPENDS += ""
PR = "r0"

SRCNAME="image_transport"

