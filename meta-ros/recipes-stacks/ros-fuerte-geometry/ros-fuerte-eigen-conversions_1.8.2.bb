require geometry.inc

DESCRIPTION = "Conversion functions between Eigen and other geometry types."
HOMEPAGE = "http://ros.org/wiki/eigen_conversions?distro=fuerte"
DEPENDS += ""
PR = "r0"

SRCNAME="eigen_conversions"

