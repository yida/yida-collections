require geometry.inc

DESCRIPTION = "This package provides a set of simple math utilities to work with angles."
HOMEPAGE = "http://www.ros.org/wiki/angles?distro=fuerte"
DEPENDS += ""
PR = "r0"

SRCNAME="angles"

