require geometry.inc

DESCRIPTION = "This package contains a set of conversion functions to convert common tf datatypes (point, vector, pose, etc) into semantically identical datatypes used by other libraries."
HOMEPAGE = "http://ros.org/wiki/tf_conversions?distro=fuerte"
DEPENDS += ""
PR = "r0"

SRCNAME="tf_conversions"

