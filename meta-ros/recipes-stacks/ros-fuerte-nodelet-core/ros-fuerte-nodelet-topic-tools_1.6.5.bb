require nodelet_core.inc

DESCRIPTION = "This package contains common nodelet tools such as a mux, demux and throttle."
HOMEPAGE = "http://www.ros.org/wiki/nodelet_topic_tools?distro=fuerte"
DEPENDS += ""
PR = "r0"

SRCNAME="nodelet_topic_tools"

