require nodelet_core.inc

DESCRIPTION = "The nodelet package is designed to provide a way to run multiple algorithms in the same process with zero copy transport between algorithms."
HOMEPAGE = "http://www.ros.org/wiki/nodelet?distro=fuerte"
DEPENDS += "ros-fuerte-bondcpp ros-fuerte-pluginlib"
PR = "r8"

SRCNAME="nodelet"

