require laser_drivers.inc

DESCRIPTION = "camera_calibration_parsers contains routines for reading and writing camera calibration parameters"
HOMEPAGE = "http://www.ros.org/wiki/camera_info_manager?distro=fuerte"
DEPENDS += "ros-fuerte-driver-base ros-fuerte-self-test ros-fuerte-diagnostic-updater ros-fuerte-dynamic-reconfigure"
PR = "r0"

SRCNAME="hokuyo_node"

