#DESCRIPTION = "Underlying library for support roscpp message data types"

VER_roscpp-core = "0.2.5"

SRC_URI += "git://github.com/wg-debs/roscpp_core-release.git;destsuffix=roscpp_core;name=roscpp-core"
SRCREV_roscpp-core = "debian/ros-fuerte-roscpp-core_${VER_roscpp-core}_lucid" 

