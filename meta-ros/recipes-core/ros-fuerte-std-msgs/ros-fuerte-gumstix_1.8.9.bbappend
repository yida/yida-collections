#DESCRIPTION = "Common message types representing primitive data types and other basic message constructs, such as multiarray"

VER_std-msgs = "0.4.8"

SRC_URI += "git://github.com/wg-debs/std_msgs-release.git;destsuffix=std_msgs;name=std-msgs"
SRCREV_std-msgs = "debian/ros-fuerte-std-msgs_${VER_std-msgs}_lucid" 

